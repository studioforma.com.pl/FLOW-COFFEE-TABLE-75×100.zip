Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Flow-Coffee table 75x100 - ver4.ifc
Time: 2025-11-11T17:15:32
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Flow-Coffee table 75x100_0 - ObjectType: SketchupGroup
 | Flow-Coffee table 75x100_1 - ObjectType: SketchupGroup
 | Flow-Coffee table 75x100_2 - ObjectType: SketchupGroup
 | Flow-Coffee table 75x100_3 - ObjectType: SketchupGroup
